# Keil uVision project Audio_Recorder_Player.uvproj, settings and files
target Audio_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Audio_Project
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\;..\Library\3rdParty\FatFs\source;..\Library\3rdParty\Adpcm;..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC1xx\Include;..\Library\Device\Nuvoton\NUC1xx\Source;..\Library\;..\Library\NUC1xx\Include;..\Library\NUC1xx-LB_002\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../Library/CMSIS/Include/: core_cm0.c
    ../Library/Device/Nuvoton/NUC1xx/Source/: system_NUC1xx.c
    ../Library/Device/Nuvoton/NUC1xx/Source/arm/: startup_NUC1xx.s
  group Source files
    ../: main.c WAU8822.c Utilities.c
  group Peripherals
    ../Library/NUC1xx/Source/: retarget.c
    ../Library/NUC1xx-LB_002/Source/: LCD.c SDCard.c Scankey.c
  group Library files
    ../Library/3rdParty/Adpcm/: libImaAdpcm4bit.lib
    ../Library/NUC1xx/Source/: GPIO.c SYS.c SPI.c I2C.c I2S.c UART.c
  group FatFs
    ../Library/3rdParty/FatFs/source/: ff.c diskio.c
